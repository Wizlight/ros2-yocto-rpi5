RPI_EXTRA_CONFIG:append = "\
camera_auto_detect=0\n\
dtoverlay=imx219\n\
"
